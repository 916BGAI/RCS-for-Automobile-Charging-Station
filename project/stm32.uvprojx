# Keil uVision project stm32.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,debug=1
  c misc: -Wno-invalid-source-encoding
  c include: ..\user;..\user\api;..\STM32F10x_StdPeriph_Driver\inc;..\ld3320;..\FatFs\Fatfs_src;..\sdCard_spi;..\user\api\MQTT;..\user\api\HMAC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../startup/: startup_stm32f10x_hd.s
  group fwlib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../user/: system_stm32f10x.c stm32f10x_it.c main.c
  group api
    ../user/api/: delay.c led.c beep.c RGB.c Key.c usart1.c dht11.c ADC.c cJSON.c esp8266.c aliyun.c lcd.c zi.c iccard.c mfrc522.c spi.c app.c
  group MQTT
    ../user/api/MQTT/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group HMAC
    ../user/api/HMAC/: utils_hmac.c utils_md5.c utils_sha1.c
software components: CMSIS:CORE 5.6.0
